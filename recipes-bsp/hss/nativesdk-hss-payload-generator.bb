require hss-payload-generator.inc
inherit nativesdk
