require hss-payload-generator.inc
inherit native
